# Keil uVision project Pet_Feeder.uvprojx, settings and files
target Pet_Feeder (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pet_Feeder +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Src\Bsp\Inc;..\Src\Core\Inc;..\Src\FWlib\Inc;..\Src\Main\Inc;..\Src\SDK\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../Src/Main/Src/: Main.c
  group Bsp
    ../Src/Bsp/Src/: Bsp_Usart.c
  group FWlib
    ../Src/FWlib/Src/: stm32f10x_gpio.c stm32f10x_it.c stm32f10x_rcc.c stm32f10x_usart.c
  group Core
    ../Src/Core/Src/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group SDK
    ../Src/SDK/Src/: mcu_api.c protocol.c system.c
